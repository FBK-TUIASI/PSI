# Keil uVision project CSC-L5.uvproj, settings and files
target BIG8051 (MCS-51)
  device: C8051F040 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Test
  c flags: Optimize=1 SizeSpeed=1
  c include: .\BIG8051\Include
  group Drivere
    ./BIG8051/Drivers/: osc.c wdt.c port.c timer.c lcd.c keyboard.c uart0.c can.c
  group Aplicatie
    ./: TestCAN.c
